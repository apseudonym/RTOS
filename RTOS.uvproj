# Keil uVision project RTOS.uvproj, settings and files
target RTOS (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOS
  c flags: Optim=1
  c include: ..;.\inc;..\..\..;..\driverlib;.\..\..\..\..\..\..\Stellarisware;C:\Stellarisware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sources
    src/: Startup.s Output.c rit128x96x4.c adc.c os.c uart.c Lab3.c
    C:/StellarisWare/utils/: uartstdio.c
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
  group Includes
    inc/: adc.h os.h Output.h rit128x96x4.h uart.h
    src/: cr4_fft_64_stm32.s PID_stm32.s
    C:/StellarisWare/utils/: uartstdio.h
